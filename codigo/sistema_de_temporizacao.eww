<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sistema_de_temporizacao.ewp</path>
    </project>
    <batchBuild />
</workspace>
